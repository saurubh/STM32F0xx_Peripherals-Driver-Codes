<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\6_steps\6_steps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\7_PWMOutputs\7_PWMOutputs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Complementary_signals\Complementary_signals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMA_Burst\DMA_Burst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Encoder_Mode\Encoder_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Input_Capture\Input_Capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\OC_Active\OC_Active.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\OC_Toggle\OC_Toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\One_Pulse\One_Pulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\PWM_Input\PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Synchronization_Mode\Synchronization_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM_ADC_Trigger\TIM_ADC_Trigger.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Time_base\Time_base.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>OC_Toggle</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>6_steps</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>7_PWMOutputs</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>Complementary_signals</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Burst</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>Encoder_Mode</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>Input_Capture</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>OC_Active</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>One_Pulse</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>Synchronization_Mode</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>TIM_ADC_Trigger</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>Time_base</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


