# IAR project I2C_WakeUpFromStop.ewp, settings and files
configuration STM320518-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F0508-EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ./: system_stm32f0xx.c
  group CPAL_Driver
    ../../../../Libraries/STM32F0xx_CPAL_Driver/src/: stm32f0xx_i2c_cpal.c stm32f0xx_i2c_cpal_hal.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_cec.c stm320518_eval_i2c_ee.c stm320518_eval_i2c_tsensor.c stm320518_eval_lcd.c stm320518_eval_spi_sd.c
  group User
    ./: main.c stm32f0xx_i2c_cpal_usercallback.c stm32f0xx_it.c
